SUMMARY = "Development image for irr_control."
LICENSE = "MIT"

require irr-control-image.bb

IMAGE_FEATURES += "debug-tweaks"
