SUMMARY = "Provides a custom configuration file for openssh."
LICENSE = "MIT"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
