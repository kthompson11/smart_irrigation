SUMMARY = "Overrides the default wpa_supplicant.conf-sane with the one in the wpa-supplicant folder."
LICENSE = "MIT"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
