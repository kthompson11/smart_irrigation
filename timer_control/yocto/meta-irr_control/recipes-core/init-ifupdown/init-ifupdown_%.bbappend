SUMMARY = "Overrides the default interfaces file with a custom version."
LICENSE = "MIT"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
