SUMMARY = "Development image for irr_control."
LICENSE = "MIT"

IMAGE_FEATURES += "debug-tweaks"
